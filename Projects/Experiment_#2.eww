<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LED_Blinking_ASM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Seven_Segment.ewp</path>
    </project>
    <batchBuild />
</workspace>
