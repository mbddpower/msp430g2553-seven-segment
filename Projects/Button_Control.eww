<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Button_Control.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LPM_Timer_Interrupt.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Seven_Segment.ewp</path>
    </project>
    <batchBuild />
</workspace>
